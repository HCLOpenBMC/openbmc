FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI +="file://0002-board-aspeed-Add-Mux-for-yosemitev2.patch"
