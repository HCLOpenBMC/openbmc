FILESEXTRAPATHS_prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://yosemitev2.cfg"
SRC_URI += "file://0001-adm1278-temperature-cfg-enable.patch"
